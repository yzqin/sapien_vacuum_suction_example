Commit message: [update] small modificaiton on convention

File: assets/xarm6/xarm6_vacuum.urdf (robot description, URDF)
Before this commit: robot xarm6, 10 links, 9 joints
Joints:
- joint joint_tcp: origin xyz=0 0 0.126 rpy=0 0 0 -> xyz=0 0 0.126 rpy=3.14159 0 0
